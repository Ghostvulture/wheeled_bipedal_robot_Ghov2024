# Keil uVision project Gimbal.uvprojx, settings and files
target Gimbal (6220000::V6.22::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Gimbal +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Src/BSP;../Src/BSP/can;../Src/BSP/dwt;../Src/BSP/gpio;../Src/BSP/iic;../Src/BSP/pwm;../Src/BSP/spi;../Src/BSP/tim;../Src/BSP/usart;../Src/Entity;../Src/Entity/board_connectivity;../Src/Entity/buzzer;../Src/Entity/daemon;../Src/Entity/Dr16;../Src/Entity/GMMotor;../Src/Entity/IMU/BMI088;../Src/Entity/IMU/IST8310;../Src/Entity/LED;../Src/Utility;../Src/GimbalController/Chassis;../Src/GimbalController;../Src/GimbalController/Gimbal;../Src/GimbalController/Shooter;../Src/Entity/IMU/AHRS;../Src/Entity/IMU/EKF;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;..\Src\BSP\usb;..\Src\GimbalController\Test;..\Src\Entity\LKMotor;..\Src\GimbalController\Test\balance_toolbox
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
    ../Drivers/CMSIS/DSP/Source/QuaternionMathFunctions/: arm_quaternion_product_f32.c
  group Entity
    ../Src/Entity/board_connectivity/: BoardConnectivity.cpp
    ../Src/Entity/buzzer/: buzzer.c
    ../Src/Entity/Dr16/: Dr16.cpp remoteControl.c
    ../Src/Entity/GMMotor/: GM2006.cpp GM3508.cpp GM6020.cpp GMMotorHandler.cpp
    ../Src/Entity/IMU/BMI088/: BMI088.cpp
    ../Src/Entity/IMU/IST8310/: IST8310.cpp
    ../Src/Entity/LED/: LED.c
    ../Src/Entity/IMU/AHRS/: AHRS.cpp
    ../Src/Entity/IMU/EKF/: kalman_filter.c QuaternionEKF.c user_lib.c
    ../Src/Entity/LKMotor/: LK8016.cpp LK9025.cpp LKMotorHandler.cpp
  group BSP
    ../Src/BSP/: bsp.c cpp_solution.cpp
    ../Src/BSP/can/: bsp_can.c
    ../Src/BSP/dwt/: bsp_dwt.c
    ../Src/BSP/gpio/: bsp_gpio.c
    ../Src/BSP/iic/: bsp_iic.c
    ../Src/BSP/spi/: bsp_spi.c
    ../Src/BSP/pwm/: bsp_pwm.c
    ../Src/BSP/tim/: bsp_tim.c
    ../Src/BSP/usart/: bsp_usart.c
  group Utility
    ../Src/Utility/: Math.cpp Pid.cpp
  group Gimbal
    ../Src/GimbalController/Gimbal/: GimbalController.cpp GimbalStateRelax.cpp GimbalStateRemoteControl.cpp GimbalStateSearch.cpp GimbalStateFPS.cpp
  group Chassis
    ../Src/GimbalController/Chassis/: ChassisController.cpp ChassisStateRelax.cpp ChassisStateRemoteControl.cpp ChassisStateRotate.cpp ChassisStateFPS.cpp
  group Shooter
    ../Src/GimbalController/Shooter/: ShooterController.cpp
  group Test
    ../Src/GimbalController/Test/: BalanceController.cpp BalanceRemoteControl.cpp BalanceSpeedControl.cpp BalanceStateRelax.cpp BalanceStandControl.cpp
    ../Src/GimbalController/Test/balance_toolbox/: balance_task.cpp
    ../Src/GimbalController/: cpp_main.cpp
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2
